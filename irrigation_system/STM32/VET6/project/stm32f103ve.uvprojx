# Keil uVision project stm32f103ve.uvprojx, settings and files
target stm32f103ve (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ve +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\startup;..\library\inc;..\user;..\driver\led;..\driver\systick;..\driver\usart;..\driver\dht11;..\driver\LED;..\driver\usart2;..\driver\TimBase
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group doc
    ../: readme.md
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group library
    ../library/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
  group driver
    ../driver/systick/: bsp_systick.c
    ../driver/usart/: bsp_usart.c
    ../driver/dht11/: bsp_dht11.c
    ../driver/usart2/: bsp_usart2.c
    ../driver/LED/: bsp_led.c
    ../driver/TimBase/: bsp_TiMbase.c
  group user
    ../user/: stm32f10x_conf.h stm32f10x_it.c main.c
